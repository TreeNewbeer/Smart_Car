# Keil uVision project TXD.uvproj, settings and files
target Project (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TXD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group User
    ./: main.c
    ./Scr/: uart.c nrf24l01.c delay.c oled12864.c
